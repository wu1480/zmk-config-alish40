## config/boards/shields/Alish40/Kconfig.defconfig
```kconfig
if SHIELD_ALISH40
        
config ZMK_KEYBOARD_NAME
    default "Alish40"

endif
```
